#Force static libraries to be built with -fPIC option
BJAM_TOOLS += "cxxflags=-fPIC cflags=-fPIC"
