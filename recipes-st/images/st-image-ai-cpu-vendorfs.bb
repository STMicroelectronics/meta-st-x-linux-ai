require recipes-st/images/st-image-vendorfs.bb

# Define a proper vendorfs for st-image-ai
STM32MP_VENDORFS_IMAGE = "st-image-ai-cpu-vendorfs"
