FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-cmake-support-git-clone-shallow-with-specified-SHA1-.patch"
