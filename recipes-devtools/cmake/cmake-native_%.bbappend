FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI += "file://${PN}/${PV}/0001-cmake-support-git-clone-shallow-with-specified-SHA1-.patch"
