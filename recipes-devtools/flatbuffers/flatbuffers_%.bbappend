#Force static libraries to be built with -fPIC option
CXXFLAGS += " -fPIC "
BUILD_CXXFLAGS += " -fPIC "
