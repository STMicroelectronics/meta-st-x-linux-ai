#Avoid meta-clang to provide libunwind
PACKAGECONFIG = ""
